# Keil uVision project TxTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F60XE STC11F32XE Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000)
  output: TxTest +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: TxTest.C
